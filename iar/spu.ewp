# IAR project spu.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x1
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\User; ..\BSP\STM8; ..\YOS; ..\INC
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: spu.hex
  ILINK.IlinkOutputFile: spu.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S103; GREE_Y502K
  OBJCOPY.OOCOutputFile: AC.hex
  postbuild: postbuild.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: YOS_STM8L152.out
  group BSP
    ../BSP/STM8/: STM8Lib.c
  group STM8
    ../User/: LED.c SPI.c TIM4.c Uart.c WDT.c
  group User
    ../User/: ciu98m25.c main.c time.c uart_app.c
  group YOS
    ../YOS/: YOS-STM8S103-V150612A-R0.a
  group YWS_LIB
    ../User/: zpyws.c
